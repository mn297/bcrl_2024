# Repository mn297/bcrl_2024 (continued)

## KiCad design kicad_files/bcrl_power_supply/bcrl_power_supply.kicad_pcb (continued)

Schematic: IND108W_EMC_8V.kicad_sch

Parts:
C117, C118, C119, C120, C121, C122: 22u; C_1206_3216Metric; DigiKey_Part_Number C3216X5R1V226M160AC
PS17: IND108W; Manufacturer_Part_Number IND108W; DigiKey_Part_Number IND108W
R55: 9.59k; R_0603_1608Metric; DigiKey_Part_Number RCS06039K53FKEA

Connections:
/TxRFswMUXv1 board/+8V_1: C117.1, C118.1, C119.1, PS17.3 (VS+), PS17.5 (VOUT); also elsewhere on the board
/TxRFswMUXv1 board/+12V: C120.1, C121.1, C122.1, PS17.9 (VIN); also elsewhere on the board
/TxRFswMUXv1 board/TxPA1_8V_CTRL: PS17.1 (ON/OFF); also elsewhere on the board
GND: C117.2, C118.2, C119.2, C120.2, C121.2, C122.2, PS17.2 (GND_1), PS17.6 (GND_2), PS17.7 (SYNC), PS17.8 (GND_3), R55.2; also elsewhere on the board
unnamed: PS17.4 (TRIM), R55.1

Parts of its further copies:
C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C105, C106, C107, C108, C109, C110, C111, C112, C113, C114, C115, C116, C123, C124, C125, C126, C127, C128: 22u; C_1206_3216Metric; DigiKey_Part_Number C3216X5R1V226M160AC
PS1, PS2, PS3, PS4, PS15, PS16, PS18: IND108W; Manufacturer_Part_Number IND108W; DigiKey_Part_Number IND108W
R14, R16, R18, R20, R51, R53, R57: 9.59k; R_0603_1608Metric; DigiKey_Part_Number RCS06039K53FKEA

Connections of its further copies:
/RxRFswMUXv1 board/+8V_1: C25.1, C26.1, C27.1, PS4.3 (VS+), PS4.5 (VOUT); also elsewhere on the board
/RxRFswMUXv1 board/+8V_2: C105.1, C106.1, C107.1, PS15.3 (VS+), PS15.5 (VOUT); also elsewhere on the board
/RxRFswMUXv1 board/+8V_3: C111.1, C112.1, C113.1, PS16.3 (VS+), PS16.5 (VOUT); also elsewhere on the board
/RxRFswMUXv1 board/+8V_4: C123.1, C124.1, C125.1, PS18.3 (VS+), PS18.5 (VOUT); also elsewhere on the board
/RxRFswMUXv1 board/+12V: C28.1, C29.1, C30.1, C108.1, C109.1, C110.1, C114.1, C115.1, C116.1, C126.1, C127.1, C128.1, PS4.9 (VIN), PS15.9 (VIN), PS16.9 (VIN), PS18.9 (VIN); also elsewhere on the board
/RxRFswMUXv1 board/RxLNA1_8V_CTRL: PS4.1 (ON/OFF); also elsewhere on the board
/RxRFswMUXv1 board/RxLNA2_8V_CTRL: PS15.1 (ON/OFF); also elsewhere on the board
/RxRFswMUXv1 board/RxLNA3_8V_CTRL: PS16.1 (ON/OFF); also elsewhere on the board
/RxRFswMUXv1 board/RxLNA4_8V_CTRL: PS18.1 (ON/OFF); also elsewhere on the board
/TxRFswMUXv1 board/+8V_2: C7.1, C8.1, C9.1, PS1.3 (VS+), PS1.5 (VOUT); also elsewhere on the board
/TxRFswMUXv1 board/+8V_3: C13.1, C14.1, C15.1, PS2.3 (VS+), PS2.5 (VOUT); also elsewhere on the board
/TxRFswMUXv1 board/+8V_4: C19.1, C20.1, C21.1, PS3.3 (VS+), PS3.5 (VOUT); also elsewhere on the board
/TxRFswMUXv1 board/+12V: C10.1, C11.1, C12.1, C16.1, C17.1, C18.1, C22.1, C23.1, C24.1, PS1.9 (VIN), PS2.9 (VIN), PS3.9 (VIN); also elsewhere on the board
/TxRFswMUXv1 board/TxPA2_8V_CTRL: PS1.1 (ON/OFF); also elsewhere on the board
/TxRFswMUXv1 board/TxPA3_8V_CTRL: PS2.1 (ON/OFF); also elsewhere on the board
/TxRFswMUXv1 board/TxPA4_8V_CTRL: PS3.1 (ON/OFF); also elsewhere on the board
GND: C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, PS1.2 (GND_1), PS1.6 (GND_2), PS1.7 (SYNC), PS1.8 (GND_3), PS2.2 (GND_1), PS2.6 (GND_2), PS2.7 (SYNC), PS2.8 (GND_3), PS3.2 (GND_1), PS3.6 (GND_2), PS3.7 (SYNC), PS3.8 (GND_3), PS4.2 (GND_1), PS4.6 (GND_2), PS4.7 (SYNC), PS4.8 (GND_3), PS15.2 (GND_1), PS15.6 (GND_2), PS15.7 (SYNC), PS15.8 (GND_3), PS16.2 (GND_1), PS16.6 (GND_2), PS16.7 (SYNC), PS16.8 (GND_3), PS18.2 (GND_1), PS18.6 (GND_2), PS18.7 (SYNC), PS18.8 (GND_3), R14.2, R16.2, R18.2, R20.2, R51.2, R53.2, R57.2; also elsewhere on the board
unnamed: PS1.4 (TRIM), R14.1
unnamed: PS2.4 (TRIM), R16.1
unnamed: PS3.4 (TRIM), R18.1
unnamed: PS4.4 (TRIM), R20.1
unnamed: PS15.4 (TRIM), R51.1
unnamed: PS16.4 (TRIM), R53.1
unnamed: PS18.4 (TRIM), R57.1

Notes on the sheet:
Rtrim = 70/(Vout - 0.7) kiloohms https://www.mouser.ca/datasheet/2/167/ind108w_ds-3402027.pdf

Schematic: IND108W_EMC_6.5V.kicad_sch

Parts:
C87, C88, C89, C90, C91, C92: 22u; C_1206_3216Metric; DigiKey_Part_Number C3216X5R1V226M160AC
PS12: IND108W; Manufacturer_Part_Number IND108W; DigiKey_Part_Number IND108W
R46: 12.06k; R_0603_1608Metric; DigiKey_Part_Number ESR03EZPJ123

Connections:
+12V_1: C90.1, C91.1, C92.1, PS12.9 (VIN); also elsewhere on the board
/BFN/+6.5V_CTRL_RxBFN_C: PS12.1 (ON/OFF); also elsewhere on the board
/BFN/+6.5V_RxBFN_C: C87.1, C88.1, C89.1, PS12.3 (VS+), PS12.5 (VOUT); also elsewhere on the board
GND: C87.2, C88.2, C89.2, C90.2, C91.2, C92.2, PS12.2 (GND_1), PS12.6 (GND_2), PS12.7 (SYNC), PS12.8 (GND_3), R46.2; also elsewhere on the board
unnamed: PS12.4 (TRIM), R46.1

Parts of its further copies:
C63, C64, C65, C66, C67, C68, C81, C82, C83, C84, C85, C86, C95, C96, C97, C98, C99, C100: 22u; C_1206_3216Metric; DigiKey_Part_Number C3216X5R1V226M160AC
PS8, PS11, PS13: IND108W; Manufacturer_Part_Number IND108W; DigiKey_Part_Number IND108W
R40, R44, R49: 12.06k; R_0603_1608Metric; DigiKey_Part_Number ESR03EZPJ123

Connections of its further copies:
+12V_1: C84.1, C85.1, C86.1, PS11.9 (VIN); also elsewhere on the board
+12V_2: C66.1, C67.1, C68.1, C98.1, C99.1, C100.1, PS8.9 (VIN), PS13.9 (VIN); also elsewhere on the board
/BFN/+6.5V_CTRL_RxBFN_F: PS11.1 (ON/OFF); also elsewhere on the board
/BFN/+6.5V_CTRL_TxBFN_C: PS8.1 (ON/OFF); also elsewhere on the board
/BFN/+6.5V_CTRL_TxBFN_F: PS13.1 (ON/OFF); also elsewhere on the board
/BFN/+6.5V_RxBFN_F: C81.1, C82.1, C83.1, PS11.3 (VS+), PS11.5 (VOUT); also elsewhere on the board
/BFN/+6.5V_TxBFN_C: C63.1, C64.1, C65.1, PS8.3 (VS+), PS8.5 (VOUT); also elsewhere on the board
/BFN/+6.5V_TxBFN_F: C95.1, C96.1, C97.1, PS13.3 (VS+), PS13.5 (VOUT); also elsewhere on the board
GND: C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C95.2, C96.2, C97.2, C98.2, C99.2, C100.2, PS8.2 (GND_1), PS8.6 (GND_2), PS8.7 (SYNC), PS8.8 (GND_3), PS11.2 (GND_1), PS11.6 (GND_2), PS11.7 (SYNC), PS11.8 (GND_3), PS13.2 (GND_1), PS13.6 (GND_2), PS13.7 (SYNC), PS13.8 (GND_3), R40.2, R44.2, R49.2; also elsewhere on the board
unnamed: PS8.4 (TRIM), R40.1
unnamed: PS11.4 (TRIM), R44.1
unnamed: PS13.4 (TRIM), R49.1

Notes on the sheet:
Rtrim = 70/(Vout - 0.7) kiloohms https://www.mouser.ca/datasheet/2/167/ind108w_ds-3402027.pdf

Schematic: PDQE15-Q48-D24-D_EMC.kicad_sch

Parts:
C46, C47: 330u; CP_Radial_D12.5mm_P5.00mm; DigiKey_Part_Number 100ZLJ330M12.5X35
C48: 47u; CP_Radial_D12.5mm_P5.00mm; rating 100v; DigiKey_Part_Number UCS2E470MHD1TO
C132, C133: 4.7u; C_1206_3216Metric; rating 100v; LCSC C784420
C135, C136: 1nf; C_0603_1608Metric; rating 2kv; DigiKey_Part_Number CGP5C102KGYDAA7301
L16: 4.7u; L_0603_1608Metric; rating 3.1a; DigiKey_Part_Number MGAH06034R7M-10
PS19: PDQE15-Q48-D24-D; CONV_PDQE15-Q48-D24-D; PARTREV 1.0; DigiKey_Part_Number PDQE15-Q48-D24-D

Connections:
48V: C46.1, C132.1, L16.1; also elsewhere on the board
/RPi_HAT/+24V: C48.1, C135.2, PS19.4 (+VO); also elsewhere on the board
/RPi_HAT/+24V_CTRL: PS19.1 (CTRL); also elsewhere on the board
/RPi_HAT/PDQE15-Q48-D24-D_EMC_2/VIN: C47.1, C133.1, C135.1, L16.2, PS19.3 (VIN)
GND: C46.2, C47.2, C48.2, C132.2, C133.2, C136.1, C136.2, PS19.2 (GND), PS19.5 (0V); also elsewhere on the board

Notes on the sheet:
https://www.cui.com/product/resource/pdqe15-d.pdf

Board: 2 copper layers, 336 parts (0 on the bottom side), 145 nets, no tracks yet.

File kicad_files/bcrl_power_supply/bcrl_psu_bom.csv:

"Reference","Value","Description","Datasheet","Footprint","Qty","rating","DNP","DigiKey_Part_Number"
"#PWR0326","GND","","","","1","","",""
"H1,H2,H3,H4,H5,H6","MountingHole_Pad","Mounting Hole with connection","~","MountingHole:MountingHole_3.5mm_Pad","6","","",""
"J3,J12,J13,J14,J15,J16,J17,J18,J19,J20,J31,J32,J33,J34,J35,J36,J37,J38,J39,J43,J44,J45,J69,J70,J71,J72,J76,J77,J79","Conn_01x02","","~","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","29","","",""
"J50,J51,J52,J53,J54,J55,J56,J57,J58,J59,J60,J61,J62,J63,J64,J65,J66,J67","Conn_01x04_Pin","","~","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical","18","","",""
"J68,J73,J74,J75,J80,J81,J82,J83","Conn_01x06_Pin","","~","Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical","8","","",""
"J21,J22,J40,J41","5034801600","","","BCRL_power_supply:MOLEX_5034801600","4","","","5034801600"
"C7,C8,C9,C10,C11,C12,C13,C14,C15,C16,C17,C18,C19,C20,C21,C22,C23,C24,C25,C26,C27,C28,C29,C30,C63,C64,C65,C66,C67,C68,C81,C82,C83,C84,C85,C86,C87,C88,C89,C90,C91,C92,C95,C96,C97,C98,C99,C100,C105,C106,C107,C108,C109,C110,C111,C112,C113,C114,C115,C116,C117,C118,C119,C120,C121,C122,C123,C124,C125,C126,C127,C128","22u","","~","Capacitor_SMD:C_1206_3216Metric","72","",""," C3216X5R1V226M160AC "
"C46,C47","330u","Polarized capacitor","~","Capacitor_THT:CP_Radial_D12.5mm_P5.00mm","2","","","100ZLJ330M12.5X35 "
"D1,D2,D3,D4,D5,D6,D7,D8,D9,D10,D11,D12,D13,D14,D16,D17,D18,D19,D20,D21,D22,D23,D24,D35,D37,D38","LED 0603","LED diode","~","LED_SMD:LED_0603_1608Metric","26","","","150060GS75000 "
"P1,P2,P3,P4,P5,P6,P7,P8","5104338-1","","","BCRL_power_supply:TE_5104338-1","8","","","5104338-1 "
"C32,C34,C43,C45,C78,C80,C102,C104","1u","Unpolarized capacitor","~","Capacitor_SMD:C_0603_1608Metric","8","50v","","C1608X5R1H105K080DB "
"C135,C136","1nf","","~","Capacitor_SMD:C_0603_1608Metric","2","2kv","","CGP5C102KGYDAA7301 "
"PS5,PS6,PS10,PS14","EHHD010A0B41-HZ","out=12V/10A in=18V-75V ","","BCRL_power_supply:CONV_EHHD010A0B41-HZ","4","","","EHHD010A0B41-HZ"
"R1,R2,R3,R4,R5,R6,R7,R8,R9,R13,R15,R17,R19,R21,R23,R24,R25,R26,R27,R28,R29,R30,R31,R59,R62,R63","1k","Resistor","~","Resistor_SMD:R_0603_1608Metric","26","","","ESR03EZPF1001 "
"R40,R44,R46,R49","12.06k","Resistor","~","Resistor_SMD:R_0603_1608Metric","4","","","ESR03EZPJ123 "
"FL1","FLT007A0Z","Power Line Filters 0-75Vdc 7A Through Hole","https://datasheet.datasheetarchive.com/originals/distributor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","BCRL_power_supply:FLT007A0Z","1","","","FLT007A0Z"
"C1,C2,C3,C4,C5,C6,C37,C38,C39,C40,C50,C51,C59,C60,C61,C62,C73,C74,C75,C76,C93,C94,C129,C130,C132,C133"," 4.7u","","~","Capacitor_SMD:C_1206_3216Metric","26","100v","","GRM31CC72A475KE11L "
"C35,C36,C41","2.2u","Unpolarized capacitor","~","Capacitor_SMD:C_1206_3216Metric","3","100v","","HMK316AC7225KL-TE "
"PS1,PS2,PS3,PS4,PS8,PS11,PS12,PS13,PS15,PS16,PS17,PS18","IND108W","Non-Isolated DC/DC Converters 12Vin 3-9V 108W 12A Neg Log SMT 33 mm x 13.46 mm x 10 mm","https://www.omnionpower.com/assets/pdfs/windchill/data-sheet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","BCRL_power_supply:IND108W","12","","","IND108W"
"L1,L2,L4,L5,L8,L10,L11,L12,L13,L14,L15,L16","4.7u","Inductor","~","Inductor_SMD:L_0603_1608Metric","12","3.1a","","MGAH06034R7M-10 "
"J1,J2,J4,J5,J6,J7,J8,J9,J10,J11,J23,J24,J25,J26,J27,J28,J29,J30,J42,J46,J47,J48,J49,J78","OSTVN02A150","","","BCRL_power_supply:CONN_OSTVN02A150_OST","24","","","OSTVN02A150"
"U3","PDQ10-Q48-S3-D","","","BCRL_power_supply:CONV_PDQ10-Q48-S3-D","1","","","PDQ10-Q48-S3-D"
"U1,U2,U5,U6,U8,U9,U10,U11,U12,U13,U14","PDQ10-Q48-S5-D","","","BCRL_power_supply:CONV_PDQ10-Q48-S5-D","11","","","PDQ10-Q48-S5-D"
"PS19","PDQE15-Q48-D24-D","","","BCRL_power_supply:CONV_PDQE15-Q48-D24-D","1","","","PDQE15-Q48-D24-D"
"R14,R16,R18,R20,R51,R53,R55,R57","9.59k","Resistor","~","Resistor_SMD:R_0603_1608Metric","8","","","RCS06039K53FKEA "
"R10,R11,R12,R32,R37,R38,R39,R42,R43,R48,R61","3.4k","Resistor","~","Resistor_SMD:R_0603_1608Metric","11","","","TNPW06033K40BEEA "
"C31,C33,C42,C44,C48,C77,C79,C101,C103","47u","-- mixed values --","~","Capacitor_THT:CP_Radial_D12.5mm_P5.00mm","9","100v","","UCS2E470MHD1TO "
